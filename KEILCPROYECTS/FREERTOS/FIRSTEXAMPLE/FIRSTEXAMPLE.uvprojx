# Keil uVision project FIRSTEXAMPLE.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: FIRSTEXAMPLE
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CMSIS_device_header=\"stm32f446xx.h\"
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: TESTTASK.c
software components: CMSIS:CORE 6.1.1, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.2.0, RTOS:Config 11.2.0, RTOS:Core 11.2.0, RTOS:Event Groups 11.2.0, RTOS:Heap 11.2.0, RTOS:Timers 11.2.0, Device:Startup 2.6.3
